# Keil uVision project dtb.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: dtb
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: Drop_The_Bass.c Drop_the_Bass.h EdgeTrigger.c EdgeTrigger.h GPIO.c GPIO.h main.c PLL.c PLL.h Registers.h ST7735.c ST7735.h Startup.s UART.c UART.h PWM.c PWM.h
